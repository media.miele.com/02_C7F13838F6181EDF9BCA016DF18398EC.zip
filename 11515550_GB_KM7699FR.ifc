Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 5e19d39d-2c0f-4f98-a72e-84c75f7c5ca9, NumberOfSaves: 1]
File name: 0001
Time: 2024-09-04T08:47:15+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11515550_GB_KM7699FR:26769900_GB_11515550_KM7699FR, (2)
In: Default
Type - Material: z_Miele_Design_CLST, z_Miele_Connection_Electric, z_Miele_Design_Glass Black, <Unnamed>, z_Miele_Design_Stainless Steel
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 942 mm; Height: 52 mm; Depth: 526 mm
Pset_BuildingElementProxyCommon - Reference: 26769900_GB_11515550_KM7699FR; sets with these values: 2
